# Keil uVision project Jupiter.uvprojx, settings and files
target Jupiter (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM7_DP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ESEL ELITTLE
  output: Jupiter +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __DCACHE_PRESENT
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\..\..\0_Library\CMSIS\Include;..\..\..\0_Library\Device\SkyRelay\SKY32B750\Include;..\..\..\0_Library\StdDriver\Include;..\..\..\0_Library\StdDriver\Include\Can;..\..\..\1_BSP\EVB1_V3.1\SDK\Inc;..\..\..\2_HAL\Inc;..\..\..\3_RTOS\freeRTOS\include;..\..\..\3_RTOS\freeRTOS\portable\RVDS\ARM_CM7\r0p1;.\SignalProcess\Inc;.\TaskManage\Inc;.\User\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ../../../0_Library/Device/SkyRelay/SKY32B750/Source/ARM/: startup_SKY32B750.s
  group Application/CMSIS
    ../../../0_Library/Device/SkyRelay/SKY32B750/Source/: system_SKY32B750.c
  group Application/Lib
    ../../../0_Library/StdDriver/Source/: delay.c mpu.c pinmux.c usci.c dma.c wdt.c fadc.c efc.c gpio.c rtc.c ospi.c timerB.c
  group Application/FreeRTOS
    ../../../3_RTOS/freeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../3_RTOS/freeRTOS/portable/MemMang/: heap_4.c
    ../../../3_RTOS/freeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Application/BSP_EVB1_V3.1
    ../../../1_BSP/EVB1_V3.1/SDK/: bsp_ADC.c bsp_GPIO.c bsp_SPI.c bsp_UART.c
  group Application/HAL
    ../../../2_HAL/: hal_BB.c hal_RF.c hal_Delay.c hal_DMA.c hal_MPU.c hal_RTC.c hal_SysClk.c hal_WDT.c hal_Timer.c hal_OSPI.c
  group Application/SignalProcess
    ./SignalProcess/: RF_Config.c BB_Config.c Radar_Config.c BB_AlgProc.c BB_PointCloudPack.c
  group Application/TaskManage
    ./TaskManage/: BB_Task.c Printf_Task.c
  group Application/User
    ./User/: main.c Usart_Protocol.c ParamConfig.c IRQ_Handler.c
